# Keil uVision project PROPELLER DISPLAY PROJECT.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: PROPELLER DISPLAY PROJECT +hex
  c flags: Optimize=8 SizeSpeed=1
  group STARTUP
    ./: STARTUP.A51
  group MAIN PROGRAM
    ./: PROPELLER DISPLAY PROJECT.C
  group HEADER FILES
    ./: CHARACTER.h DISPLAYY.h INITIALIZESYSTEM.h SERIALRECIVE.h
